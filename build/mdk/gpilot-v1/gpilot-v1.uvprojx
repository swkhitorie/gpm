# Keil uVision project gpilot-v1.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gpilot-v1 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=6 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\..\boards\st\stdf1\v3.6.0\core;..\..\..\boards\st\stdf1\v3.6.0\driver;..\..\..\boards\st\stdf1\v3.6.0\user;..\..\..\platforms\lld_svc;..\..\..\platforms
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group board
    ../../../boards/st/stdf1/v3.6.0/core/: core_cm3.c
    ../../../boards/st/stdf1/v3.6.0/driver/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../../../boards/st/stdf1/v3.6.0/user/: stm32f10x_it.c system_stm32f10x.c
    ../../../boards/st/stdf1/v3.6.0/startup/arm/: startup_stm32f10x_hd.s
  group platform
    ../../../platforms/: ttscheduler.c devfifobuffer.c llddebug.c
    ../../../platforms/lld_svc/stdf1/: lld_kernel.c lld_gpio.c lld_interrupt.c lld_uart.c lld_adc.c lld_dac.c lld_exit.c lld_spi.c lld_i2c.c lld_timer.c
  group app
    ../../../src/app/gpilot-v1/: main.c
