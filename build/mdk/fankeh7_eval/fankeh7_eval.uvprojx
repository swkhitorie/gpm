# Keil uVision project fankeh7_eval.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: fankeh7_eval +hex
  AfterMake: .\build_bin.bat
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=6 wLevel=3
  c define: USE_HAL_DRIVER,STM32H743xx, __clang__
  c misc: -Wno-empty-body -Wno-macro-redefined -Wno-invalid-source-encoding -Wno-writable-strings
  c include: ..\..\..\boards\fankeh7\src\core;..\..\..\boards\fankeh7\src\drivers;..\..\..\boards\fankeh7\src\drivers\Legacy;..\..\..\boards\fankeh7\src;..\..\..\platforms\common;..\..\..\platforms\component\lld_svc\cubeh7
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\..\..\boards\fankeh7\fankeh7_lnk_arm.sct
  group board
    ../../../boards/fankeh7/src/drivers/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_wwdg.c
    ../../../boards/fankeh7/src/: stm32h7xx_hal_msp.c stm32h7xx_it.c system_stm32h7xx.c
    ../../../boards/fankeh7/: fankeh7_startup_arm.s
  group lld
    ../../../platforms/component/lld_svc/cubeh7/: lld_board_kernel.c lld_can.c lld_exirq.c lld_flash.c lld_gpio.c lld_i2c.c lld_interrupt.c lld_iwdg.c lld_kernel.c lld_spi.c lld_timer.c lld_uart.c
    ../../../platforms/common/: devfifobuffer.c llddebug.c serialization.c ttscheduler.c
  group app
    ../../../src/app/fankeh7_eval/: app_main.c
