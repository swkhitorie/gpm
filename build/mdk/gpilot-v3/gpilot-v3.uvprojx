# Keil uVision project gpilot-v3.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: gpilot-v3
  group boards
    ../../../boards/st/cubeh7/v1.11.2/drivers/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c
    ../../../boards/st/cubeh7/v1.11.2/user/: stm32h7xx_hal_msp.c stm32h7xx_it.c system_stm32h7xx.c
    ../../../boards/st/cubeh7/v1.11.2/startup/gcc/: startup_stm32h743xx.s
  group platform
    ../../../platforms/: ttscheduler.c devfifobuffer.c llddebug.c
    ../../../platforms/lld_svc/cubeh7/: lld_kernel.c lld_board_kernel.c lld_interrupt.c lld_iwdg.c lld_flash.c lld_gpio.c lld_exirq.c lld_spi.c lld_uart.c lld_i2c.c lld_can.c lld_timer.c
  group main
    ../../../src/app/gpilot-v3/: main.c
