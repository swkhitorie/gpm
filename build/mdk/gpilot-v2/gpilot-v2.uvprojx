# Keil uVision project gpilot-v2.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gpilot-v2
  AfterMake: D:\__dev_envir\__env\arm_gcc\gcc-arm-none-eabi\bin\arm-none-eabi-objcopy.exe -O binary .\output\gpilot-v2.elf .\output\gpilot-v2.bin
  group board
    ../../../boards/st/stdf4/v1.9.0/driver/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
    ../../../boards/st/stdf4/v1.9.0/user/: stm32f4xx_it.c system_stm32f4xx.c
    ../../../boards/st/stdf4/v1.9.0/startup/gcc_ride7/: startup_stm32f40_41xxx.s
  group platform
    ../../../platforms/: ttscheduler.c devfifobuffer.c llddebug.c
    ../../../platforms/lld_svc/stdf4/: lld_kernel.c lld_interrupt.c lld_gpio.c lld_flash.c lld_uart.c lld_adc.c lld_dac.c lld_exit.c lld_spi.c lld_i2c.c lld_timer.c
  group app
    ../../../src/app/gpilot-v2/: main.c
