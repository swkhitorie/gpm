# Keil uVision project gpilot.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: gpilot +hex
  AfterMake: .\build_bin.bat
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=6 wLevel=3
  c define: USE_HAL_DRIVER,STM32H743xx, __clang__
  c misc: -Wno-empty-body -Wno-macro-redefined -Wno-invalid-source-encoding -Wno-writable-strings
  c include: ..\..\..\boards\st\h7_hal\include;..\..\..\boards\st\usb_device_library_1;..\..\..\platforms;..\..\..\platforms\mem;..\..\..\platforms\drvs_boards;..\..\..\platforms\drvs_boards\st\usb;..\..\..\src\include\container;..\..\..\src\include\data_model;..\..\..\src\include\gdev;..\..\..\src\lib;..\..\..\src\lib\fatfs\src;..\..\..\src\lib\fatfs\src\drivers;..\..\..\src\drivers;..\..\..\src\modules;..\..\..\src\modules\uORB;..\..\..\src\modules\mavlink;..\..\..\src\modules\mavlink\v2;..\..\..\src\modules\mavlink\v2\all;..\..\..\src\app\gpilot
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\ld_gpilot.sct
  group boards
    ../../../boards/st/h7_hal/src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_mdma.c stm32h7xx_hal_msp.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_wwdg.c stm32h7xx_it.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_sdmmc.c system_stm32h7xx.c stm32h7xx_ll_usb.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c
    ../../../boards/st/h7_hal/init/: startup_stm32h743xx.s
  group platforms\mem
    ../../../platforms/mem/: ememredirect.cpp emonitor.cpp
    ../../../platforms/mem/mmu/: rtos_mem_1.cpp rtos_mem_2.cpp rtx_mem.cpp
  group platforms\boards
    ../../../platforms/drvs_boards/st/h7/: h7_adc.cpp h7_can.cpp h7_cpuflash.cpp h7_exirq.cpp h7_gpio.cpp h7_hsem.cpp h7_i2c.cpp h7_iwdg.cpp h7_kernel.cpp h7_qspi.cpp h7_sdio.cpp h7_spi.cpp h7_timer.cpp h7_uart.cpp h7_wwdg.cpp
  group lib\utility
    ../../../src/lib/utility/: co_scheduler.cpp log.cpp serialize.cpp thread_manager.cpp
  group lib\fatfs
    ../../../src/lib/fatfs/src/: diskio.c ff.c ff_gen_drv.c
    ../../../src/lib/fatfs/src/option/: syscall.c unicode.c
    ../../../src/lib/fatfs/src/drivers/: sd_diskio_dma.cpp
  group lib\protocol
    ../../../src/lib/protocol/: nmea0813_parser.cpp
  group lib\math
    ../../../src/lib/geo/: geo.cpp geodesicGrid.cpp
    ../../../src/lib/world_magnetic_model/: geo_mag_declination.cpp
    ../../../src/lib/conversion/: rotation.cpp
    ../../../src/lib/controllib/: BlockHighPass.cpp BlockLowPass.cpp
    ../../../src/lib/terrain_estimation/: terrain_estimator2.cpp
  group lib\ecl
    ../../../src/lib/ecl/geo/: geo_old.cpp
    ../../../src/lib/ecl/EKF/: airspeed_fusion.cpp control.cpp covariance.cpp drag_fusion.cpp ekf.cpp ekf_helper.cpp EKFGSF_yaw.cpp estimator_interface.cpp gps_checks.cpp gps_yaw_fusion.cpp imu_down_sampler.cpp mag_control.cpp mag_fusion.cpp optflow_fusion.cpp sensor_range_finder.cpp sideslip_fusion.cpp terrain_estimator.cpp utils.cpp vel_pos_fusion.cpp
  group lib\sensor_calibration
    ../../../src/lib/sensor_calibration/: gyro_calibrator.cpp accel_calibrator.cpp accel_calibrator_bak.cpp compass_calibrator.cpp compass_calibrator_bak.cpp
  group modules\uorb_topics
    ../../../src/modules/uORB/: uORB_topic_define.cpp
  group modules\param
    ../../../src/modules/param/: param.cpp
  group modules\mavlink
    ../../../src/modules/mavlink/: mavlink_vehicle.cpp mavlink_receiver.cpp mavlink_transfer.cpp mavlink_command.cpp mavlink_mission.cpp mavlink_parameters.cpp mavlink_log.cpp mavlink_ftp.cpp
  group modules\sensors
    ../../../src/modules/sensors/: sensor_imu.cpp sensor_compass.cpp sensor_gps.cpp
  group modules\attitude_estimator
    ../../../src/modules/attitude_estimator/: attitude_estimator.cpp attitude_estimator_q.cpp madgwickAHRS.c
  group modules\local_estimator
    ../../../src/modules/local_position_estimator/sensors/: baro.cpp flow.cpp gps.cpp land.cpp landing_target.cpp lidar.cpp mocap.cpp sonar.cpp vision.cpp
    ../../../src/modules/local_position_estimator/: local_position_estimator.cpp
  group modules\ekf2
    ../../../src/modules/ekf2/Utility/: PreFlightChecker.cpp
    ../../../src/modules/ekf2/: ekf2.cpp
  group drivers
    ../../../src/drivers/: led.cpp
    ../../../src/drivers/imu/: mpu6050.cpp
    ../../../src/drivers/compass/: qmc5883l.cpp hmc5883l.cpp
    ../../../src/drivers/barometer/: ms5611.cpp
    ../../../src/drivers/gps/: nmea0813.cpp ublox.cpp
    ../../../src/drivers/flash/: at24cxx.cpp
    ../../../src/drivers/adc/: ads1220l.cpp
    ../../../src/drivers/dac/: mcp4716.cpp
    ../../../src/drivers/uwb/: linktrack_aoa.cpp
    ../../../src/drivers/distance_sensor/: dypa21.cpp
    ../../../src/drivers/rc_input/: sbus.cpp
  group main
    ../../../src/app/gpilot/: main.cpp interface.cpp fat_fs.cpp sensor_group.cpp gcs_client.cpp navigator.cpp rover_pos_control.cpp bsp_debug.cpp bsp_gundampilot.cpp
