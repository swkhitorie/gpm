# Keil uVision project bootloader_px4usb.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: bootloader_px4usb +hex
  AfterMake: .\build_bin.bat
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=6 wLevel=3
  c define: USE_HAL_DRIVER,STM32H743xx, __clang__
  c misc: -Wno-empty-body -Wno-macro-redefined -Wno-invalid-source-encoding -Wno-writable-strings -Wno-implicit-function-declaration
  c include: ..\..\..\boards\st\h7_hal\include;..\..\..\boards\st\usb_device_library_1;..\..\..\platforms;..\..\..\platforms\mem;..\..\..\platforms\drvs_boards;..\..\..\platforms\drvs_boards\st\usb;..\..\..\platforms\CherryUSB\common;..\..\..\platforms\CherryUSB\core;..\..\..\platforms\CherryUSB\class\cdc;..\..\..\src\include\container;..\..\..\src\include\data_model;..\..\..\src\include\gdev;..\..\..\src\lib;..\..\..\src\drivers;..\..\..\src\modules;..\..\..\src\app\bootloader_px4usb
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\ld_bootloader_px4usb.sct
  group boards
    ../../../boards/st/h7_hal/src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_mdma.c stm32h7xx_hal_msp.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_wwdg.c stm32h7xx_it.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_sdmmc.c system_stm32h7xx.c stm32h7xx_ll_usb.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c
    ../../../boards/st/h7_hal/init/: startup_stm32h743xx.s
  group platforms\cherryUSB
    ../../../platforms/CherryUSB/core/: usbd_core.c
    ../../../platforms/CherryUSB/class/cdc/: usbd_cdc.c
    ../../../platforms/CherryUSB/port/dwc2/: usb_dc_dwc2.c usb_glue_st.c
    ../../../platforms/CherryUSB/demo/: cdc_acm_template.c
  group main
    ../../../src/app/bootloader_px4usb/: cherryusb_interface.c bl_kernel.c bl_flash.c bl_board.c bl.c main.c
